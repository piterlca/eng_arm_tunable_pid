# Keil uVision project Digital_controller.uvproj, settings and files
target Digital_controller (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: LPC2478 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x4000FFFF) IRAM2(0x7FE00000-0x7FE03FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: Digital_controller +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x10000
  memory RVCT10: RAM 0x7fe00000 size 0x4000
  group Source Group 1
    ./: LPC2300.s main.c SSP0_SPI.c irq.c Timer.c SSP1_SPI.c PLL.c PID.c Buffer.c UART1.c sys_buf.c sbuffer.c
  group Headers
    ./: irq.h Type.h Timer.h SSP1_SPI.h PLL.h SSP0_SPI.h LPC24xx.h PID.h UART1.h Buffer.h sys_buf.h sbuffer.h
